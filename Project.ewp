# IAR project Project.ewp, settings and files
configuration STM32L152RC (32L152C-DISCOVERY) (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZC ST STM32L152ZC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MDP
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32L-DISCOVERY
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32L152-EVAL.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L152RB (STM32L-DISCOVERY) (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152VB ST STM32L152VB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../src/: system_stm32l1xx.c
  group Doc
    ../: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s
  group StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group STM32L_DISCOVERY
    ../../../Utilities/STM32L-DISCOVERY/: stm32l_discovery_lcd.c
  group User
    ../src/: main.c stm32l1xx_it.c usart.c
